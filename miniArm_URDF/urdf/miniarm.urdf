Commit message: 增加了碰撞近似体积处理

File: miniArm_URDF/urdf/miniarm.urdf (robot description, URDF)
Before this commit: robot mini1, 7 links, 6 joints
Links:
- link link6: geometry collision mesh filename=../meshes_dae/link6.dae; visual mesh filename=../meshes/link6.STL
